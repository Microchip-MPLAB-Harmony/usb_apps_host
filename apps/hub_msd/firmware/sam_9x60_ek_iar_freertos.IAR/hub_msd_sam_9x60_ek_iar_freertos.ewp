# IAR project hub_msd_sam_9x60_ek_iar_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: .; ..\src\config\sam_9x60_ek_iar_freertos\system\fs\fat_fs\file_system; ..\src\config\sam_9x60_ek_iar_freertos\system\fs\fat_fs\hardware_access; ..\src; ..\src\config\sam_9x60_ek_iar_freertos; ..\src\packs\SAM9X60_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS; ..\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\ARM926; ..\src\third_party\rtos\FreeRTOS\Source\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_9x60_ek_iar_freertos.out
  ILINK.IlinkIcfFile: ..\src\config\sam_9x60_ek_iar_freertos\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/: app.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos
    ../src/config/sam_9x60_ek_iar_freertos/: device.h device_cache.h toolchain_specifics.h definitions.h interrupts.h FreeRTOSConfig.h user.h configuration.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/driver
    ../src/config/sam_9x60_ek_iar_freertos/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/driver/usb
    ../src/config/sam_9x60_ek_iar_freertos/driver/usb/: drv_usb.h drv_usb_external_dependencies.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/driver/usb/uhp
    ../src/config/sam_9x60_ek_iar_freertos/driver/usb/uhp/: drv_usb_ehci.h drv_usb_ohci.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/driver/usb/uhp/src
    ../src/config/sam_9x60_ek_iar_freertos/driver/usb/uhp/src/: drv_usb_ehci_local.h drv_usb_ohci_local.h drv_usb_uhp_ohci_registers.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/usb
    ../src/config/sam_9x60_ek_iar_freertos/usb/: usb_host_client_driver.h usb_host_hub_interface.h usb_host.h usb_hub.h usb_ehci.h usb_ohci.h usb_common.h usb_chapter_9.h usb_host_hub.h usb_host_msd.h usb_host_scsi.h usb_msd.h scsi.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/usb/src
    ../src/config/sam_9x60_ek_iar_freertos/usb/src/: usb_host_local.h usb_host_hub_mapping.h usb_external_dependencies.h usb_host_hub_local.h usb_host_msd_local.h usb_host_scsi_local.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/bsp
    ../src/config/sam_9x60_ek_iar_freertos/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/system
    ../src/config/sam_9x60_ek_iar_freertos/system/: system.h system_common.h system_module.h system_media.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/system/fs
    ../src/config/sam_9x60_ek_iar_freertos/system/fs/: sys_fs.h sys_fs_media_manager.h sys_fs_fat_interface.h
    ../src/config/sam_9x60_ek_iar_freertos/system/fs/src/: sys_fs_local.h sys_fs_media_manager_local.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/system/fs/fat_fs/file_system
    ../src/config/sam_9x60_ek_iar_freertos/system/fs/fat_fs/file_system/: ff.h ffconf.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/system/fs/fat_fs/hardware_access
    ../src/config/sam_9x60_ek_iar_freertos/system/fs/fat_fs/hardware_access/: diskio.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/system/int
    ../src/config/sam_9x60_ek_iar_freertos/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/system/cache
    ../src/config/sam_9x60_ek_iar_freertos/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/system/debug
    ../src/config/sam_9x60_ek_iar_freertos/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/system/time
    ../src/config/sam_9x60_ek_iar_freertos/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_9x60_ek_iar_freertos/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/peripheral/pit
    ../src/config/sam_9x60_ek_iar_freertos/peripheral/pit/: plib_pit.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/peripheral/mmu
    ../src/config/sam_9x60_ek_iar_freertos/peripheral/mmu/: plib_mmu.h cp15.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/peripheral/clk
    ../src/config/sam_9x60_ek_iar_freertos/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/peripheral/pio
    ../src/config/sam_9x60_ek_iar_freertos/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/peripheral/aic
    ../src/config/sam_9x60_ek_iar_freertos/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/peripheral/tc
    ../src/config/sam_9x60_ek_iar_freertos/peripheral/tc/: plib_tc0.h plib_tc_common.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar_freertos/osal
    ../src/config/sam_9x60_ek_iar_freertos/osal/: osal.h osal_definitions.h osal_freertos.h
  group Harmony3/Header Files/packs/SAM9X60_DFP
    ../src/packs/SAM9X60_DFP/: sam9x60.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/component
    ../src/packs/SAM9X60_DFP/component/: adc.h aes.h aic.h bsc.h can.h classd.h dbgu.h emac.h flexcom.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pio.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc.h tdes.h trng.h udphs.h uhpfs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/instance
    ../src/packs/SAM9X60_DFP/instance/: adc.h aes.h aic.h bsc.h can0.h can1.h classd.h dbgu.h emac0.h emac1.h flexcom0.h flexcom1.h flexcom10.h flexcom11.h flexcom12.h flexcom2.h flexcom3.h flexcom4.h flexcom5.h flexcom6.h flexcom7.h flexcom8.h flexcom9.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pioa.h piob.h pioc.h piod.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc0.h sdmmc1.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc0.h tc1.h tdes.h trng.h udphs.h uhphs_ehci.h uhphs_ohci.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/pio
    ../src/packs/SAM9X60_DFP/pio/: sam9x60.h
  group Harmony3/Header Files/FreeRTOS/Source/include
    ../src/third_party/rtos/FreeRTOS/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h deprecated_definitions.h task.h timers.h mpu_prototypes.h stream_buffer.h message_buffer.h
  group Harmony3/Header Files/FreeRTOS/Source/portable/IAR/SAM/ARM926
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/ARM926/: portmacro.h
  group Harmony3/Source Files
    ../src/: main.c app.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar_freertos
    ../src/config/sam_9x60_ek_iar_freertos/: usb_host_init_data.c initialization.c interrupts.c cstartup.s vectortrap.s freertos_hooks.c tasks.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar_freertos/driver/usb/uhp/src
    ../src/config/sam_9x60_ek_iar_freertos/driver/usb/uhp/src/: drv_usb_ehci.c drv_usb_ohci.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar_freertos/usb/src
    ../src/config/sam_9x60_ek_iar_freertos/usb/src/: usb_host.c usb_host_hub.c usb_host_msd.c usb_host_scsi.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar_freertos/bsp
    ../src/config/sam_9x60_ek_iar_freertos/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar_freertos/system/fs
    ../src/config/sam_9x60_ek_iar_freertos/system/fs/src/: sys_fs.c sys_fs_media_manager.c sys_fs_fat_interface.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar_freertos/system/fs/fat_fs/file_system
    ../src/config/sam_9x60_ek_iar_freertos/system/fs/fat_fs/file_system/: ff.c ffunicode.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar_freertos/system/fs/fat_fs/hardware_access
    ../src/config/sam_9x60_ek_iar_freertos/system/fs/fat_fs/hardware_access/: diskio.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar_freertos/system/int
    ../src/config/sam_9x60_ek_iar_freertos/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar_freertos/system/cache
    ../src/config/sam_9x60_ek_iar_freertos/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar_freertos/system/time
    ../src/config/sam_9x60_ek_iar_freertos/system/time/src/: sys_time.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar_freertos/peripheral/pit
    ../src/config/sam_9x60_ek_iar_freertos/peripheral/pit/: plib_pit.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar_freertos/peripheral/mmu
    ../src/config/sam_9x60_ek_iar_freertos/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar_freertos/peripheral/clk
    ../src/config/sam_9x60_ek_iar_freertos/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar_freertos/peripheral/pio
    ../src/config/sam_9x60_ek_iar_freertos/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar_freertos/peripheral/aic
    ../src/config/sam_9x60_ek_iar_freertos/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar_freertos/peripheral/tc
    ../src/config/sam_9x60_ek_iar_freertos/peripheral/tc/: plib_tc0.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar_freertos/stdio
    ../src/config/sam_9x60_ek_iar_freertos/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar_freertos/osal
    ../src/config/sam_9x60_ek_iar_freertos/osal/: osal_freertos.c
  group Harmony3/Source Files/FreeRTOS/Source
    ../src/third_party/rtos/FreeRTOS/Source/: croutine.c list.c queue.c FreeRTOS_tasks.c timers.c event_groups.c stream_buffer.c
  group Harmony3/Source Files/FreeRTOS/Source/portable/MemMang
    ../src/third_party/rtos/FreeRTOS/Source/portable/MemMang/: heap_1.c
  group Harmony3/Source Files/FreeRTOS/Source/portable/IAR/SAM/ARM926
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/ARM926/: port.c portASM.s FreeRTOS_tick_config.c
  group Harmony3/Linker File
    ../src/config/sam_9x60_ek_iar_freertos/: ddram.icf
