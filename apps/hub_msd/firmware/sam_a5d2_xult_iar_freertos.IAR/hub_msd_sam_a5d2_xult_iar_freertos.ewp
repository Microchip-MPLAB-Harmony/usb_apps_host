# IAR project hub_msd_sam_a5d2_xult_iar_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCIncludePath2: ..\src; ..\src\config\sam_a5d2_xult_iar_freertos; ..\src\packs\ATSAMA5D27_DFP; ..\src\packs\CMSIS\CMSIS\Core_A\Include; ..\src\packs\CMSIS; .; ..\src\config\sam_a5d2_xult_iar_freertos\system\fs\fat_fs\file_system; ..\src\config\sam_a5d2_xult_iar_freertos\system\fs\fat_fs\hardware_access; ..\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\CA5; ..\src\third_party\rtos\FreeRTOS\Source\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\CA5; ..\src\config\sam_a5d2_xult_iar_freertos; .
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_a5d2_xult_iar_freertos.out
  ILINK.IlinkIcfFile: ..\src\config\sam_a5d2_xult_iar_freertos\ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/: app.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos
    ../src/config/sam_a5d2_xult_iar_freertos/: device_cache.h toolchain_specifics.h definitions.h device.h FreeRTOSConfig.h user.h configuration.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/usb
    ../src/config/sam_a5d2_xult_iar_freertos/usb/: usb_host_msd.h usb_host_scsi.h usb_msd.h scsi.h usb_host_client_driver.h usb_host_hub_interface.h usb_host.h usb_hub.h usb_ehci.h usb_ohci.h usb_common.h usb_chapter_9.h usb_host_hub.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/usb/src
    ../src/config/sam_a5d2_xult_iar_freertos/usb/src/: usb_host_msd_local.h usb_host_scsi_local.h usb_host_local.h usb_host_hub_mapping.h usb_external_dependencies.h usb_host_hub_local.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/peripheral/pit
    ../src/config/sam_a5d2_xult_iar_freertos/peripheral/pit/: plib_pit.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/peripheral/mmu
    ../src/config/sam_a5d2_xult_iar_freertos/peripheral/mmu/: plib_mmu.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/peripheral/matrix
    ../src/config/sam_a5d2_xult_iar_freertos/peripheral/matrix/: plib_matrix.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/peripheral/l2cc
    ../src/config/sam_a5d2_xult_iar_freertos/peripheral/l2cc/: plib_l2cc.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/peripheral/clk
    ../src/config/sam_a5d2_xult_iar_freertos/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/peripheral/pio
    ../src/config/sam_a5d2_xult_iar_freertos/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/peripheral/aic
    ../src/config/sam_a5d2_xult_iar_freertos/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/peripheral/tc
    ../src/config/sam_a5d2_xult_iar_freertos/peripheral/tc/: plib_tc0.h plib_tc_common.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/peripheral/uart
    ../src/config/sam_a5d2_xult_iar_freertos/peripheral/uart/: plib_uart_common.h plib_uart1.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/system
    ../src/config/sam_a5d2_xult_iar_freertos/system/: system.h system_common.h system_module.h system_media.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/system/time
    ../src/config/sam_a5d2_xult_iar_freertos/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_a5d2_xult_iar_freertos/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/system/fs
    ../src/config/sam_a5d2_xult_iar_freertos/system/fs/: sys_fs.h sys_fs_media_manager.h sys_fs_fat_interface.h
    ../src/config/sam_a5d2_xult_iar_freertos/system/fs/src/: sys_fs_local.h sys_fs_media_manager_local.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/system/fs/fat_fs/file_system
    ../src/config/sam_a5d2_xult_iar_freertos/system/fs/fat_fs/file_system/: ff.h ffconf.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/system/fs/fat_fs/hardware_access
    ../src/config/sam_a5d2_xult_iar_freertos/system/fs/fat_fs/hardware_access/: diskio.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/system/int
    ../src/config/sam_a5d2_xult_iar_freertos/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/system/cache
    ../src/config/sam_a5d2_xult_iar_freertos/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/system/debug
    ../src/config/sam_a5d2_xult_iar_freertos/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/driver
    ../src/config/sam_a5d2_xult_iar_freertos/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/driver/usb
    ../src/config/sam_a5d2_xult_iar_freertos/driver/usb/: drv_usb.h drv_usb_external_dependencies.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/driver/usb/uhp
    ../src/config/sam_a5d2_xult_iar_freertos/driver/usb/uhp/: drv_usb_ehci.h drv_usb_ohci.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/driver/usb/uhp/src
    ../src/config/sam_a5d2_xult_iar_freertos/driver/usb/uhp/src/: drv_usb_ehci_local.h drv_usb_ohci_local.h drv_usb_uhp_ohci_registers.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/bsp
    ../src/config/sam_a5d2_xult_iar_freertos/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar_freertos/osal
    ../src/config/sam_a5d2_xult_iar_freertos/osal/: osal.h osal_definitions.h osal_freertos.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP
    ../src/packs/ATSAMA5D27_DFP/: atsama5d27.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/component
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/pio
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core_A/Include
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_cp15.h core_ca.h
  group Harmony3/Header Files/FreeRTOS/Source/include
    ../src/third_party/rtos/FreeRTOS/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h deprecated_definitions.h task.h timers.h mpu_prototypes.h stream_buffer.h message_buffer.h
  group Harmony3/Header Files/FreeRTOS/Source/portable/IAR/SAM/CA5
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/CA5/: portASM.h portmacro.h
  group Harmony3/Source Files
    ../src/: main.c app.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos
    ../src/config/sam_a5d2_xult_iar_freertos/: initialization.c interrupts.c cstartup.s fault_handlers.c usb_host_init_data.c freertos_hooks.c tasks.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/usb/src
    ../src/config/sam_a5d2_xult_iar_freertos/usb/src/: usb_host_msd.c usb_host_scsi.c usb_host.c usb_host_hub.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/peripheral/pit
    ../src/config/sam_a5d2_xult_iar_freertos/peripheral/pit/: plib_pit.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/peripheral/mmu
    ../src/config/sam_a5d2_xult_iar_freertos/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/peripheral/matrix
    ../src/config/sam_a5d2_xult_iar_freertos/peripheral/matrix/: plib_matrix.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/peripheral/l2cc
    ../src/config/sam_a5d2_xult_iar_freertos/peripheral/l2cc/: plib_l2cc.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/peripheral/clk
    ../src/config/sam_a5d2_xult_iar_freertos/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/peripheral/pio
    ../src/config/sam_a5d2_xult_iar_freertos/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/peripheral/aic
    ../src/config/sam_a5d2_xult_iar_freertos/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/peripheral/tc
    ../src/config/sam_a5d2_xult_iar_freertos/peripheral/tc/: plib_tc0.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/peripheral/uart
    ../src/config/sam_a5d2_xult_iar_freertos/peripheral/uart/: plib_uart1.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/stdio
    ../src/config/sam_a5d2_xult_iar_freertos/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/system/time
    ../src/config/sam_a5d2_xult_iar_freertos/system/time/src/: sys_time.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/system/fs
    ../src/config/sam_a5d2_xult_iar_freertos/system/fs/src/: sys_fs.c sys_fs_media_manager.c sys_fs_fat_interface.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/system/fs/fat_fs/file_system
    ../src/config/sam_a5d2_xult_iar_freertos/system/fs/fat_fs/file_system/: ff.c ffunicode.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/system/fs/fat_fs/hardware_access
    ../src/config/sam_a5d2_xult_iar_freertos/system/fs/fat_fs/hardware_access/: diskio.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/system/int
    ../src/config/sam_a5d2_xult_iar_freertos/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/system/cache
    ../src/config/sam_a5d2_xult_iar_freertos/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/driver/usb/uhp/src
    ../src/config/sam_a5d2_xult_iar_freertos/driver/usb/uhp/src/: drv_usb_ehci.c drv_usb_ohci.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/bsp
    ../src/config/sam_a5d2_xult_iar_freertos/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar_freertos/osal
    ../src/config/sam_a5d2_xult_iar_freertos/osal/: osal_freertos.c
  group Harmony3/Source Files/FreeRTOS/Source
    ../src/third_party/rtos/FreeRTOS/Source/: croutine.c list.c queue.c FreeRTOS_tasks.c timers.c event_groups.c stream_buffer.c
  group Harmony3/Source Files/FreeRTOS/Source/portable/MemMang
    ../src/third_party/rtos/FreeRTOS/Source/portable/MemMang/: heap_1.c
  group Harmony3/Source Files/FreeRTOS/Source/portable/IAR/SAM/CA5
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/CA5/: port.c portASM.s FreeRTOS_tick_config.c
  group Harmony3/Linker File
    ../src/config/sam_a5d2_xult_iar_freertos/: ddr.icf
